# Keil uVision project SlotMachine.uvproj, settings and files
target SlotMachine (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SlotMachine +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
